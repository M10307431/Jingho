# IAR project CC2540_BASE.ewp, settings and files
configuration GPIO_test (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: xCC2540DK_V1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2540F256_banked.xcl
configuration TIMER_test (8051, debug)
  as the first configuration, except:
configuration INTERRUPT_test (8051, debug)
  as the first configuration, except:
configuration ADC_test (8051, debug)
  as the first configuration, except:
configuration WATCHDOG_test (8051, debug)
  as the first configuration, except:
configuration SLEEP_test (8051, debug)
  as the first configuration, except:
configuration JOYSTICK_test (8051, debug)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2540F256_banked.xcl
configuration LCD_test (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LCD_SUPPORT
configuration DS18B20_test (8051, debug)
  as the first configuration, except:
configuration RELAY_test (8051, debug)
  as the first configuration, except:
configuration SMOKE_test (8051, debug)
  as the first configuration, except:
configuration IR-SWITCH_test (8051, debug)
  as the first configuration, except:
configuration SPI-FLASH_test (8051, debug)
  as the first configuration, except:
configuration UART-RS232_test (8051, debug)
  as the first configuration, except:
configuration DHT11_test (8051, debug)
  as the first configuration, except:
  group (top)
    ../Source/: ADC_test.c Common.c DHT11.c DS18B20_test.c GPIO_Test.c Hal_lcd.c Hal_lcd.h INTERRUPT_Test.c IR-SWITCH_test.c JOYSTICK_test.c RELAY_test.c SLEEP_test.c SMOKE_test.c SPI-FLASH_test.c TIMER_Test.c UART-RS232_test.c WATCHDOG_test.c
